# Keil uVision project IoTPatch.uvprojx, settings and files
target IoTPatch (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32L475VETx STMicroelectronics
  pack: Keil.STM32L4xx_DFP.2.4.0
  cpu: IRAM(0x20000000,0x00018000) IRAM2(0x10000000,0x00008000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: IoTPatch +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER STM32L475xx CUSTOM_DEFINE SYS_CORTEX_M4 STM32L475_NO_OS DEV_STM32L475 USE_KEIL
  c include: ..\USER;..\CORE;..\HALLIB\STM32L4xx_HAL_Driver\Inc;..\HALLIB\STM32L4xx_HAL_Driver\Inc\Legacy;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\SPI3;..\HARDWARE\KEY;..\HARDWARE\MALLOC;..\USMART;...;;..\..\..\PatchCore\libebpf;..\..\..\PatchCore\app;..\..\..\PatchCore\hotpatch;..\..\..\PatchCore\.;MY_SEP;..\..\..\..\Runtime\libebpf;..\..\..\..\Runtime\app;..\..\..\..\Runtime\hotpatch;..\..\..\..\Runtime\.
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  memory RVCT10: RAM 0x10000000 size 0x8000
  group USER
    ./: main.c stm32l4xx_it.c system_stm32l4xx.c
  group CORE
    ../CORE/: cmsis_armcc.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h startup_stm32l475xx.s
  group HALLIB
    ../HALLIB/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c
  group SYSTEM
    ../SYSTEM/sys/: sys.c sys.h
    ../SYSTEM/delay/: delay.c delay.h
    ../SYSTEM/usart/: usart.c usart.h
  group HARDWARE
    ../HARDWARE/LED/: led.c led.h
    ../HARDWARE/BEEP/: beep.c beep.h
    ../HARDWARE/KEY/: key.c key.h
    ../HARDWARE/TIMER/: timer.c timer.h
    ../HARDWARE/LCD/: lcd.c lcd.h
    ../HARDWARE/SPI3/: spi3.c spi3.h
    ../HARDWARE/MALLOC/: malloc.c malloc.h
  group USMART
    ../USMART/: usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
  group README
    ../: readme.txt
  group MyApp
    ../../../../Runtime/app/: ihp_cli.h ihp_cli.c dummy_cve.h dummy_cve.c ihp_config.h ihp_porting.c cve_trigger.h ihp_porting.h rt_app.h rt_app.c
  group HotPatch
    ../../../../Runtime/hotpatch/include/: iotpatch.h patch_point.h utils.h defs.h fixed_patch_point_def.h
    ../../../../Runtime/hotpatch/src/: iotpatch.c utils.c ebpf_test.c cortex-m4_fbp.c patch_service.c profiling.c flash_api.c fixed_patch_points.c dynamic_patch_load.c fixed_patch_load.c jit_dev_test.c
  group eBPF
    ../../../../Runtime/libebpf/include/: ebpf.h hashmap.h ebpf_porting.h
    ../../../../Runtime/libebpf/src/: hashmap.c ebpf_inst.h ebpf_allocator.c ebpf_vm.c jit.c jit_thumb2.c
