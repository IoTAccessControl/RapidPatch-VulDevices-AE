# Keil uVision project IoTPatch.uvprojx, settings and files
target IK-52840DK (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.27.1
  cpu: IRAM(0x20000000,0x00040000) IROM(0x00000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: nrf52840_qiaa +hex
  c flags: Optim=3 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOA_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192 DCORTEX SYS_CORTEX_M4 DEV_NRF52 USE_KEIL NRF52_NO_OS  DEV_NRF52840CUSTOM_DEFINE SYS_CORTEX_M4 NRF52_NO_OS DEV_NRF52840 USE_KEIL
  c misc: --reduce_paths
  c include: ..\config;..\..\components\boards;..\..\components\drivers_nrf\nrf_soc_nosd;..\..\components\libraries\delay;..\..\components\libraries\util;..\..\components\libraries\strerror;..\..\components\libraries\log;..\..\components\libraries\log\src;..\..\components\libraries\experimental_section_vars;..\..\components\libraries\memobj;..\..\components\libraries\balloc;..\..\components\libraries\ringbuf;..\..\components\libraries\atomic;..\..\components\libraries\uart;..\..\components\libraries\fifo;..\..\external\fprintf;..\..\external\segger_rtt;..\..\integration\nrfx;..\..\integration\nrfx\legacy;..\..\modules\nrfx;..\..\modules\nrfx\hal;..\..\modules\nrfx\mdk;..\..\modules\nrfx\drivers\include;..\..\..\..\Main\hotpatch;..\..\..\..\Main\app;..\..\..\..\Main\libebpf;..\..\..\..\Main\.;..\..\..\..\Main\hotpatch\src;..\..\..\..\PatchCore\libebpf;..\..\..\..\PatchCore\app;..\..\..\..\PatchCore\hotpatch;..\..\..\..\PatchCore\.SEPSEP;MY_SEP;..\..\..\..\..\RapidPatch-Runtime-AE\libebpf;..\..\..\..\..\RapidPatch-Runtime-AE\app;..\..\..\..\..\RapidPatch-Runtime-AE\hotpatch;..\..\..\..\..\RapidPatch-Runtime-AE\.
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x40000
  link misc: --diag_suppress 6330
  group Application
    ../../app/: main.c
    ../config/: sdk_config.h
  group Board Definition
    ../../components/boards/: boards.c
  group nRF_Drivers
    ../../modules/nrfx/soc/: nrfx_atomic.c
    ../../integration/nrfx/legacy/: nrf_drv_uart.c
    ../../modules/nrfx/drivers/src/: nrfx_uart.c nrfx_uarte.c
    ../../modules/nrfx/drivers/src/prs/: nrfx_prs.c
  group nRF_Libraries
    ../../components/libraries/util/: app_error.c nrf_assert.c app_util_platform.c app_error_handler_keil.c app_error_weak.c
    ../../components/libraries/strerror/: nrf_strerror.c
    ../../external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../components/libraries/ringbuf/: nrf_ringbuf.c
    ../../components/libraries/memobj/: nrf_memobj.c
    ../../components/libraries/atomic/: nrf_atomic.c
    ../../components/libraries/balloc/: nrf_balloc.c
    ../../components/libraries/fifo/: app_fifo.c
    ../../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../../components/libraries/mem_manager/: mem_manager.c mem_manager.h
  group nRF_Log
    ../../components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_backend_uart.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c
  group MyApp
    ../../../../../RapidPatch-Runtime-AE/app/: ihp_cli.h ihp_cli.c dummy_cve.h dummy_cve.c ihp_config.h ihp_porting.c cve_trigger.h ihp_porting.h rt_app.h rt_app.c
  group HotPatch
    ../../../../../RapidPatch-Runtime-AE/hotpatch/include/: iotpatch.h patch_point.h utils.h defs.h fixed_patch_point_def.h
    ../../../../../RapidPatch-Runtime-AE/hotpatch/src/: iotpatch.c utils.c ebpf_test.c cortex-m4_fbp.c patch_service.c profiling.c flash_api.c fixed_patch_points.c dynamic_patch_load.c fixed_patch_load.c jit_dev_test.c
  group eBPF
    ../../../../../RapidPatch-Runtime-AE/libebpf/include/: ebpf.h hashmap.h ebpf_porting.h
    ../../../../../RapidPatch-Runtime-AE/libebpf/src/: hashmap.c ebpf_inst.h ebpf_allocator.c ebpf_vm.c jit.c jit_thumb2.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.27.1
