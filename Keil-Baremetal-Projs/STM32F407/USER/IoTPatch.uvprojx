# Keil uVision project IoTPatch.uvprojx, settings and files
target IoTPatch (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: MALLOC +hex
  c flags: Optim=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER   CUSTOM_DEFINE SYS_CORTEX_M4 STM32F407_NO_OS USE_KEIL
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\SRAM;..\MALLOC;..\FWLIB\inc;MY_SEP;..\..\..\..\Runtime\libebpf;..\..\..\..\Runtime\app;..\..\..\..\Runtime\hotpatch;..\..\..\..\Runtime\.
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/SRAM/: sram.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_usart.c
  group MALLOC
    ../MALLOC/: malloc.c
  group README
    ../: readme.txt
  group MyApp
    ../../../../Runtime/app/: ihp_cli.h ihp_cli.c dummy_cve.h dummy_cve.c ihp_config.h ihp_porting.c cve_trigger.h ihp_porting.h rt_app.h rt_app.c
  group HotPatch
    ../../../../Runtime/hotpatch/include/: iotpatch.h patch_point.h utils.h defs.h fixed_patch_point_def.h
    ../../../../Runtime/hotpatch/src/: iotpatch.c utils.c ebpf_test.c cortex-m4_fbp.c patch_service.c profiling.c flash_api.c fixed_patch_points.c dynamic_patch_load.c fixed_patch_load.c jit_dev_test.c
  group eBPF
    ../../../../Runtime/libebpf/include/: ebpf.h hashmap.h ebpf_porting.h
    ../../../../Runtime/libebpf/src/: hashmap.c ebpf_inst.h ebpf_allocator.c ebpf_vm.c jit.c jit_thumb2.c
